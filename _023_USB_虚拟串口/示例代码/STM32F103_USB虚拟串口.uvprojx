# Keil uVision project STM32F103_USB虚拟串口.uvprojx, settings and files
target STM32F103 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\User;..\System;.\Libraries\CMSIS;.\Libraries\CMSIS\startup;.\Libraries\FWlib\inc;.\Libraries\FWlib\src;.\bsp\w25qxx;.\bsp\CAN;.\bsp\key;.\bsp\LED;.\bsp\USART;.\bsp\XPT2046;.\bsp\ESP8266;.\bsp\DHT11;.\bsp\BH1750;.\USB\CONFIG;.\USB\STM32_USB-FS-Device_Driver\inc;.\bsp\LCD_ILI9341
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./User/: main.c stm32f10x_it.c stm32f10x_conf.h
  group BSP
    ./bsp/LED/: bsp_led.c
    ./bsp/USART/: bsp_usart.c
  group SYSTEM
    ./System/: system_f103.c
  group STARTUP
    ./Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c stm32f10x.h
  group FWLB
    ./Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USB_CONFIG
    ./USB/CONFIG/: bsp_usb.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USB_CORE
    ./USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
